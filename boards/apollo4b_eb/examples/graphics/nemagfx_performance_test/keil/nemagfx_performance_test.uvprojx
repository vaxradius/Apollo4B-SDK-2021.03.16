# Keil uVision project nemagfx_performance_test.uvprojx, settings and files
target nemagfx_performance_test (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_performance_test
  AfterMake: fromelf --bin --output bin\nemagfx_performance_test.bin bin\nemagfx_performance_test.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_performance_test.txt bin\nemagfx_performance_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_TSI_MALLOC BAREMETAL NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK PLATFORM=apollo4b_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PACKAGE_BGA AM_PART_APOLLO4B keil
  c include: ../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../utils;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../mcu/apollo4b/hal;../src;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../mcu/apollo4b;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c DejaVuSerif27pt4b.c main.c nemagfx_performance_test.c simhei16pt4b.c simhei18pt4b.c simhei26pt4b.c simhei27pt4b.c simhei36pt4b.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_mspi_psram_aps12808l.c am_devices_nemadc_rm67162.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
