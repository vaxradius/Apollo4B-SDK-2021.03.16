# Keil uVision project hello_world.uvprojx, settings and files
target hello_world (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAP42KK-KBR-sblA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.6
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: fromelf --bin --output bin\hello_world.bin bin\hello_world.axf
  AfterMake: fromelf -cedrst --output bin\hello_world.txt bin\hello_world.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4B AM_PACKAGE_BGA keil
  c include: ../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../CMSIS/ARM/Include;../src;../../../../bsp;../../../../../..;../../../../../../mcu/apollo4b;../../../../../../utils
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c hello_world.c am_hal_pwrctrl_2HW_0416.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
