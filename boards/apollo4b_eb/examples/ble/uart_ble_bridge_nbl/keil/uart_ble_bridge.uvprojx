# Keil uVision project uart_ble_bridge.uvprojx, settings and files
target uart_ble_bridge (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAP42KK-KBR-nbl Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.6
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_ble_bridge
  AfterMake: fromelf --bin --output bin\uart_ble_bridge.bin bin\uart_ble_bridge.axf
  AfterMake: fromelf -cedrst --output bin\uart_ble_bridge.txt bin\uart_ble_bridge.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA BLE_BRIDGE_SINGLE_MODE AM_PART_APOLLO4B keil
  c include: ../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../../../../bsp;../../../../../../mcu/apollo4b/hal;../../../../../../utils;../../../../../../third_party/cordio/wsf/include;../../../../../../ambiq_ble/apps/dtm_module;../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper;../src;../../../../../../third_party/cordio/wsf/sources/port/freertos;../../../../../../mcu/apollo4b;../../../../../..;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c am_util_ble_cooper.c uart_ble_bridge.c
  group devices
    ../../../../../../devices/: am_devices_cooper.c
  group dtm_module
    ../../../../../../ambiq_ble/apps/dtm_module/: dtm_main.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
