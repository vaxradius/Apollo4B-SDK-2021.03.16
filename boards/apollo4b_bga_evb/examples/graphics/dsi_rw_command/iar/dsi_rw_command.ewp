# IAR project dsi_rw_command.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; PLATFORM=apollo4b_nemagfx; AM_PART_APOLLO4B; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; BAREMETAL; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TSI_MALLOC; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\src; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dsi_rw_command.bin
  ILINK.IlinkOutputFile: dsi_rw_command.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; PLATFORM=apollo4b_nemagfx; AM_PART_APOLLO4B; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; BAREMETAL; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TSI_MALLOC; AM_PACKAGE_BGA
  group (top)
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: am_resources.c dsi_rw_command.c main.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
