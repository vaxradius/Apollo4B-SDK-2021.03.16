# Keil uVision project nemagfx_watch_gui.uvprojx, settings and files
target nemagfx_watch_gui (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_watch_gui
  AfterMake: fromelf --bin --output bin\nemagfx_watch_gui.bin bin\nemagfx_watch_gui.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_watch_gui.txt bin\nemagfx_watch_gui.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib USE_TSI_MALLOC PLATFORM=apollo4b_nemagfx AM_PART_APOLLO4B NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK AM_PACKAGE_BGA AM_FREERTOS keil
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/FreeRTOSv10.1.1/Source/include;../src/generated/NemaGUI;../src/generated/assets/images;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../devices;../../../../../../mcu/apollo4b;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../src;../src/generated/assets/fonts;../src/generated;../../../../../../utils;../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_watch_gui.c rtos.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
  group NemaGUI
    ../src/generated/NemaGUI/: main.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group FreeRTOSv10.1.1_Source
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib
